# Repository Keenan-sad/terrarium-hardware

File README.md:

# ESP32 based terrarium controller

This controller is built for terrariums with reptiles to maintain a given temperature during the day and the night.
## Features
- ESP32 WROOM 32
- 6 x 5v i2c & 1wire sensors
- 3 x 5v SSR 
- i2c LCD
- i2c RTC DS3231M
- i2c multiplexer TCA9548APWR
- cp2102 USB to UART
- usb-c for power and flashing

# Images

## KiCad design controller/pcb/terrarium.kicad_pcb

Parts:
ALED1: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
BT1: LIR2032; CR2032_vertical
C1: 10pF; C_1206_3216Metric
C7, C8, C9: 10nF; C_1206_3216Metric
D1, D2, D3: M7; D_2010_5025Metric
D4: 1N47xxA; D_2010_5025Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad_Via
I2C1: LCD; JST_XH_B4B-XH-AM_1x04_P2.50mm_Vertical
K1, K2, K3: G3MB-202P; RELAY_G3MB-202P
LED1, LED2, LED3: ACTIVE; LED_1206_3216Metric
LED4: PWR; LED_1206_3216Metric
LED6: RX; LED_1206_3216Metric
LED7: TX; LED_1206_3216Metric
PWR1: data; PinHeader_1x01_P2.54mm_Vertical
Q1, Q2, Q3: S8050; SOT-23
R1, R3, R4, R5: 150ohm; R_1206_3216Metric
R2, R22, R23: 470; R_1206_3216Metric
R6, R7, R14, R24: 5k; R_1206_3216Metric
R8, R9: 4.7k; R_1206_3216Metric
R11, R15, R16, R21: 10k; R_1206_3216Metric
R12: 3k; R_1206_3216Metric
R13: 100k; R_1206_3216Metric
S0: Power 220 in; TerminalBlock_bornier-2_P5.08mm
S1, S2, S3: Lamp 1 Out; TerminalBlock_bornier-2_P5.08mm
SW1: RST; SW_Tactile_SPST_Angled_PTS645Vx39-2LFS
U1: ESP32-WROOM-32
U2: DS3231M; SOIC-16W_7.5x10.3mm_P1.27mm
U5: TCA9548APWR; TSSOP-24_4.4x7.8mm_P0.65mm
UART1: data; PinHeader_1x06_P2.54mm_Vertical
UART2: Nextion; JST_XH_B4B-XH-AM_1x04_P2.50mm_Vertical

Connections:
220L: K1.2 (L2), K2.2 (L2), K3.2 (L2), S0.1
220N: S0.2, S1.2, S2.2, S3.2
+3V3: R8.1, R9.2, R11.1, R12.1, R24.1, U1.2 (VDD), U2.2 (VCC), U5.24 (VCC), UART1.2; also elsewhere on the board
+5V: ALED1.1 (VDD), C1.1, D1.2 (A), D2.2 (A), D3.2 (A), I2C1.2, LED1.2 (A), LED2.2 (A), LED3.2 (A), PWR1.1, UART2.1; also elsewhere on the board
EN: R11.2, SW1.2, U1.3 (EN), UART1.6; also elsewhere on the board
G4: R3.1, U1.26 (IO4)
G5: R1.1, U1.29 (IO5)
G13: U1.16 (IO13)
G16: U1.27 (IO16); also elsewhere on the board
G17: U1.28 (IO17); also elsewhere on the board
G18: U1.30 (IO18); also elsewhere on the board
G19: U1.31 (IO19); also elsewhere on the board
G23: R5.1, U1.37 (IO23)
G25: R4.1, U1.10 (IO25)
G26: U1.11 (IO26); also elsewhere on the board
G27: U1.12 (IO27); also elsewhere on the board
G32: U1.8 (IO32); also elsewhere on the board
G33: R13.1, U1.9 (IO33)
GND: ALED1.3 (VSS), BT1.2 (-), C1.2, I2C1.1, LED4.1 (K), Q1.2 (E), Q2.2 (E), Q3.2 (E), R15.1, R16.1, R21.1, SW1.1, U1.1 (GND), U1.15 (GND), U1.38 (GND), U1.39 (GND), U2.5 (GND), U2.6 (GND), U2.7 (GND), U2.8 (GND), U2.9 (GND), U2.10 (GND), U2.11 (GND), U2.12 (GND), U2.13 (GND), U5.1 (A0), U5.2 (A1), U5.12 (GND), U5.21 (A2), UART1.1, UART2.4; also elsewhere on the board
IO0: U1.25 (IO0), UART1.5; also elsewhere on the board
unnamed: ALED1.4 (DIN), R5.2
unnamed: BT1.1 (+), D4.2 (A)
unnamed: C7.1, K1.3 (+), R2.2
unnamed: C7.2, K1.4 (-), Q1.3 (C), R14.2
unnamed: C8.1, K2.3 (+), R22.2
unnamed: C8.2, K2.4 (-), Q2.3 (C), R6.2
unnamed: C9.1, K3.3 (+), R23.2
unnamed: C9.2, K3.4 (-), Q3.3 (C), R7.2
unnamed: D1.1 (K), R2.1
unnamed: D2.1 (K), R22.1
unnamed: D3.1 (K), R23.1
unnamed: D4.1 (K), R13.2, U2.14 (VBAT)
unnamed: K1.1 (L1), S1.1
unnamed: K2.1 (L1), S2.1
unnamed: K3.1 (L1), S3.1
unnamed: LED1.1 (K), R14.1
unnamed: LED2.1 (K), R6.1
unnamed: LED3.1 (K), R7.1
unnamed: LED4.2 (A), R24.2
unnamed: LED6.2 (A), LED7.2 (A), R12.2
unnamed: Q1.1 (B), R1.2, R15.2
unnamed: Q2.1 (B), R3.2, R16.2
unnamed: Q3.1 (B), R4.2, R21.2
RX: LED6.1 (K), U1.34 (RXD0/IO3), UART1.4, UART2.3; also elsewhere on the board
SCL: I2C1.4, R9.1, U1.36 (IO22), U2.16 (SCL), U5.22 (SCL)
SCL_0: U5.11 (SC3); also elsewhere on the board
SCL_1: U5.5 (SC0); also elsewhere on the board
SCL_2: U5.7 (SC1); also elsewhere on the board
SCL_3: U5.9 (SC2); also elsewhere on the board
SCL_4: U5.14 (SC4); also elsewhere on the board
SCL_5: U5.16 (SC5); also elsewhere on the board
SDA: I2C1.3, R8.2, U1.33 (IO21), U2.15 (SDA), U5.23 (SDA)
SDA_0: U5.10 (SD3); also elsewhere on the board
SDA_1: U5.4 (SD0); also elsewhere on the board
SDA_2: U5.6 (SD1); also elsewhere on the board
SDA_3: U5.8 (SD2); also elsewhere on the board
SDA_4: U5.13 (SD4); also elsewhere on the board
SDA_5: U5.15 (SD5); also elsewhere on the board
TX: LED7.1 (K), U1.35 (TXD0/IO1), UART1.3, UART2.2; also elsewhere on the board

Notes on the sheet:
External device connectors
Relays
Status LED
ESP32 WROOM 32
DS3231 rtc
Mount holes
i2c multiplex / sensors

Parts:
C2: 10uF; C_1206_3216Metric
C3: 47uF; C_1206_3216Metric
C4: 4.7uF; C_1206_3216Metric
C5, C6: 100nF; C_1206_3216Metric
P1: USB_C_Plug_USB2.0; USB_C_Receptacle_Palconn_UTC16-G
Q5, Q6: BC817; SOT-23
R18: 1M; R_1206_3216Metric
R19, R20: 10k; R_1206_3216Metric
S4: PWR; JST_XH_B2B-XH-AM_1x02_P2.50mm_Vertical
U3: LM1117-3.3; SOT-223-3_TabPin2
U4: CP2102N-A02-GQFN24; Silicon_Labs-CP2102N-A02-GQFN24-IPC_A; mouser part number 634-CP2102NA02GQFN24; digikey description IC USB TO UART BRIDGE QFN24

Connections:
+3V3: C3.1, U3.2 (VO); also elsewhere on the board
+5V: C2.1, C4.1, C6.1, P1.A4 (VBUS), P1.A9 (VBUS), P1.B4 (VBUS), P1.B9 (VBUS), S4.1, U3.3 (VI), U4.7, U4.8; also elsewhere on the board
EN: Q5.3 (C); also elsewhere on the board
GND: C2.2, C3.2, C4.2, C5.2, C6.2, P1.A1 (GND), P1.A12 (GND), P1.B1 (GND), P1.B12 (GND), R18.2, S4.2, U3.1 (GND), U4.3, U4.29; also elsewhere on the board
IO0: Q6.3 (C); also elsewhere on the board
unnamed: C5.1, U4.6
unnamed: P1.A6 (D+), U4.4
unnamed: P1.A7 (D-), U4.5
unnamed: P1.S1 (SHIELD), R18.1
unnamed: Q5.1 (B), R19.2
unnamed: Q5.2 (E), R20.1, U4.24
unnamed: Q6.1 (B), R20.2
unnamed: Q6.2 (E), R19.1, U4.28
RX: U4.26; also elsewhere on the board
TX: U4.25; also elsewhere on the board

Board: 4 copper layers, 90.0 x 90.0 mm, 81 parts (0 on the bottom side), 69 nets.

Other parts of the board:
C10: 0.47uF; C_1206_3216Metric
LED5: SNS; LED_1206_3216Metric
Q4: S8050; SOT-23
R10: 5k; R_1206_3216Metric
R17: 150ohm; R_1206_3216Metric
SENS0: 1; JST_XH_B5B-XH-AM_1x05_P2.50mm_Vertical
SENS1: 2; JST_XH_B5B-XH-AM_1x05_P2.50mm_Vertical
SENS2: 3; JST_XH_B5B-XH-AM_1x05_P2.50mm_Vertical
SENS3: 4; JST_XH_B5B-XH-AM_1x05_P2.50mm_Vertical
SENS4: 5; JST_XH_B5B-XH-AM_1x05_P2.50mm_Vertical
SENS5: 6; JST_XH_B5B-XH-AM_1x05_P2.50mm_Vertical

Their connections:
+5V: LED5.2, SENS0.3, SENS1.3, SENS2.3, SENS3.3, SENS4.3, SENS5.3; also elsewhere on the board
EN: C10.1; also elsewhere on the board
G16: SENS0.5; also elsewhere on the board
G17: SENS1.5; also elsewhere on the board
G18: SENS2.5; also elsewhere on the board
G19: SENS3.5; also elsewhere on the board
G26: SENS5.5; also elsewhere on the board
G27: SENS4.5; also elsewhere on the board
G32: R17.1; also elsewhere on the board
GND: C10.2, Q4.2; also elsewhere on the board
unnamed: LED5.1, R10.1
unnamed: Q4.1, R17.2
unnamed: Q4.3, R10.2, SENS0.4, SENS1.4, SENS2.4, SENS3.4, SENS4.4, SENS5.4
SCL_0: SENS0.2; also elsewhere on the board
SCL_1: SENS1.2; also elsewhere on the board
SCL_2: SENS2.2; also elsewhere on the board
SCL_3: SENS3.2; also elsewhere on the board
SCL_4: SENS4.2; also elsewhere on the board
SCL_5: SENS5.2; also elsewhere on the board
SDA_0: SENS0.1; also elsewhere on the board
SDA_1: SENS1.1; also elsewhere on the board
SDA_2: SENS2.1; also elsewhere on the board
SDA_3: SENS3.1; also elsewhere on the board
SDA_4: SENS4.1; also elsewhere on the board
SDA_5: SENS5.1; also elsewhere on the board

## Commit log

2021-11-30 STL and f3d for case and screen
2021-12-01 add DHT22 sensor case & lid
2021-12-02 add pcb project
2021-12-02 add v1.1 pcb
2021-12-06 add 3rd relay for lamp
2021-12-10 final changes in pcb v1.2
2021-12-10 fix labels
2021-12-10 update traces
2021-12-13 pcb v1.2 released
2021-12-14 pcb: add rtc ds3231m
2021-12-15 pcb: add esp32
2021-12-15 rearrange components
2021-12-15 wip: move to smd
2021-12-15 update smd components
2021-12-16 pcb: developing smd layout
2021-12-16 Add copper plate, minor changes
2021-12-18 pcb: v1.3 minor changes
2021-12-19 pcb updates
2021-12-19 pcb: updates
2021-12-22 pcb v1.3 finished
2022-01-11 Pcb/v1.4 (#3)
    * pcb: refactor
    * minor updates, bjt to sot-23
    * rtc charge, refactoring
    * update jst footprints, added missing 3d models
    * refactoring
    * minor changes
2022-01-11 add images of PCB
2022-01-16 wip sensor pcb
2022-01-17 working on pcb/1v1.5
2022-01-18 wip, added all footprints
2022-01-18 place components for v1.5
2022-01-20 almost done
2022-01-23 update footprints, move rx/tx leds
2022-01-23 add cp2102
2022-01-24 add ground, 5v inner planes
2022-01-24 add multiplexer for i2c, rearrange everything
2022-01-25 fix CP2102, minor bugs
2022-02-04 minor updates for cp2102
2022-03-25 Controller pcb/v1.6 (#4)
    * working on pcb/1v1.5
    * wip, added all footprints
    * place components for v1.5
    * almost done
    * update footprints, move rx/tx leds
    * add cp2102
2022-04-02 move components around
